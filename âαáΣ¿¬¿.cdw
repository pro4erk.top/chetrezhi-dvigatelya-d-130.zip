# KOMPAS-3D drawing (âαáΣ¿¬¿.cdw)

Texts:
  QFS
  VKY
  ]Ma
  PIR
  TLV
  XNZ
  ]O\PZ
  WWU[S
  PmOuN
  NBO
  SJU
  XM[
Dimensions and other numbers on the sheet: 6